options:
  parameters:
    author: gr-nut
    description: 'nut_sink video example: a vector source holding one frame of eight vertical color bars (white/yellow/cyan/green/magenta/red/blue/black, rgb24, row-major) repeats it into the NUT Video Sink, which cuts the byte stream into frames, stamps pts from the frame count and feeds a spawned ffmpeg encoding H.264 to /tmp/bars.mkv. A K0 chain: no pacer anywhere, the graph free-runs and renders `seconds` seconds of video in a fraction of that. Play the result with any video player.'
    generate_options: no_gui
    id: video_bars
    output_language: python
    run_options: run
    title: gr-nut video bars example
  states: {}

blocks:
- name: command
  id: parameter
  parameters:
    comment: |-
      spawn mode: full shell command
      reading NUT on stdin
    label: Spawn Command (spawn mode)
    type: str
    value: ffmpeg -y -loglevel warning -i pipe:0 -c:v libx264 -preset veryfast -pix_fmt yuv420p /tmp/bars.mkv
  states: {}
- name: uri
  id: parameter
  parameters:
    comment: |-
      external mode: FIFO/file
      read by your own ffmpeg
    label: NUT FIFO/file (external mode)
    type: str
    value: ''
  states: {}
- name: seconds
  id: parameter
  parameters:
    label: Seconds of video
    type: eng_float
    value: '5'
  states: {}
- name: width
  id: variable
  parameters:
    comment: |-
      declared to the sink: it writes the
      NUT headers and cuts frames at
      width*height*3 bytes
    value: '320'
  states: {}
- name: height
  id: variable
  parameters:
    value: '240'
  states: {}
- name: fps
  id: variable
  parameters:
    value: '25'
  states: {}
- name: bars
  id: variable
  parameters:
    comment: |-
      one rgb24 frame, row-major: eight
      vertical bars, pixel x takes color
      x*8//width
    value: '[c for y in range(height) for x in range(width) for c in [(255, 255, 255), (255, 255, 0), (0, 255, 255), (0, 255, 0), (255, 0, 255), (255, 0, 0), (0, 0, 255), (0, 0, 0)][x * 8 // width]]'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: |-
      the media source: one frame of
      bars, repeated forever
    repeat: 'True'
    type: byte
    vector: bars
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    comment: |-
      bounds the recording to whole
      frames; without a pacer the
      graph free-runs (K0)
    num_items: int(seconds * fps) * width * height * 3
    type: byte
  states: {}
- name: nut_nut_sink_video_0
  id: nut_nut_sink_video
  parameters:
    command: command
    comment: |-
      declares 320x240@25, writes the
      headers, synthesizes pts from the
      frame count; on stop: flush ->
      trailer -> EOF -> wait for ffmpeg
    flush_timeout: '10.0'
    fps: '[fps]'
    heights: '[height]'
    uri: uri
    video_streams: '1'
    widths: '[width]'
  states: {}

connections:
- [blocks_vector_source_x_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', nut_nut_sink_video_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
