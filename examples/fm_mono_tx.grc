options:
  parameters:
    author: gr-nut
    description: 'M1 mono FM transmitter: NUT ingest -> 48k -> 200k (25/6) -> WBFM mono (+-75 kHz, 50 us preemphasis) -> 200k -> 8M (40/1) -> HackRF. The HackRF is the only clock; ffmpeg is paced by pipe backpressure. No Throttle. Spawn mode showcase: pass --command "ffmpeg -i song.flac -vn -af aresample=48000:async=1 -ac 1 -c:a pcm_f32le -max_interleave_delta 500000 -f nut pipe:1" and the block runs ffmpeg itself. Ops variant: fm_mono_tx.sh starts ffmpeg externally and passes --uri FIFO instead.'
    generate_options: no_gui
    id: fm_mono_tx
    output_language: python
    run_options: run
    title: gr-nut M1 mono FM transmitter
  states: {}

blocks:
- name: uri
  id: parameter
  parameters:
    comment: |-
      external mode: FIFO/file
      written by your own ffmpeg
    label: NUT FIFO/file (external mode)
    type: str
    value: ''
  states: {}
- name: command
  id: parameter
  parameters:
    comment: |-
      spawn mode: full shell command
      writing NUT to stdout, e.g.
      ffmpeg -i song.flac -vn -af aresample=48000:async=1
      -ac 1 -c:a pcm_f32le -max_interleave_delta 500000
      -f nut pipe:1
    label: Spawn Command (spawn mode)
    type: str
    value: ffmpeg -i song.flac -vn -af aresample=48000:async=1 -ac 1 -c:a pcm_f32le -max_interleave_delta 500000 -f nut pipe:1
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Center Frequency (Hz)
    type: eng_float
    value: 99.9e6
  states: {}
- name: vga_gain
  id: parameter
  parameters:
    label: HackRF VGA Gain (0-47 dB)
    type: eng_float
    value: '40'
  states: {}
- name: amp
  id: parameter
  parameters:
    label: HackRF Amp (0/1, +14 dB)
    type: intx
    value: '0'
  states: {}
- name: nut_nut_source_audio_0
  id: nut_nut_source_audio
  parameters:
    audio_channels: '1'
    audio_rate: '48000'
    command: command
    comment: |-
      set exactly one of command/uri;
      backpressure paces ffmpeg
    uri: uri
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: 48 kHz -> 200 kHz (exact 25/6)
    decim: '6'
    interp: '25'
    type: fff
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '200000'
    comment: |-
      mono WBFM: +-75 kHz deviation,
      50 us preemphasis, no pilot
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: '200000'
    tau: '50e-6'
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    comment: 200 kHz -> 8 MHz (exact 40/1)
    decim: '1'
    interp: '40'
    type: ccc
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: bool(amp)
    center_freq: freq
    comment: |-
      the only clock in the graph
      (8 MSPS, HackRF practical minimum)
    samp_rate: 8e6
    type: fc32
    vga: vga_gain
  states: {}

connections:
- [nut_nut_source_audio_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_tx_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_1, '0', soapy_hackrf_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
