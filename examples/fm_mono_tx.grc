options:
  parameters:
    author: gr-nut
    description: 'M1 mono FM transmitter: NUT ingest -> 48k -> 200k (25/6) -> WBFM mono (+-75 kHz, 50 us preemphasis) -> 200k -> 8M (40/1) -> HackRF. The HackRF is the only clock; ffmpeg is paced by pipe backpressure. No Throttle.'
    generate_options: no_gui
    id: fm_mono_tx
    output_language: python
    run_options: run
    title: gr-nut M1 mono FM transmitter
  states: {}

blocks:
- name: uri
  id: parameter
  parameters:
    label: NUT FIFO/file
    type: str
    value: /tmp/fm_mono.nut
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Center Frequency (Hz)
    type: eng_float
    value: 99.9e6
  states: {}
- name: vga_gain
  id: parameter
  parameters:
    label: HackRF VGA Gain (0-47 dB)
    type: eng_float
    value: '40'
  states: {}
- name: amp
  id: parameter
  parameters:
    label: HackRF Amp (0/1, +14 dB)
    type: intx
    value: '0'
  states: {}
- name: nut_nut_source_0
  id: nut_nut_source
  parameters:
    audio_channels: '1'
    audio_rate: '48000'
    comment: |-
      ffmpeg writes the FIFO;
      backpressure paces it
    emit_video: 'False'
    repeat: 'False'
    uri: uri
    video_height: '0'
    video_width: '0'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: 48 kHz -> 200 kHz (exact 25/6)
    decim: '6'
    interp: '25'
    type: fff
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '200000'
    comment: |-
      mono WBFM: +-75 kHz deviation,
      50 us preemphasis, no pilot
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: '200000'
    tau: '50e-6'
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    comment: 200 kHz -> 8 MHz (exact 40/1)
    decim: '1'
    interp: '40'
    type: ccc
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: bool(amp)
    center_freq: freq
    comment: |-
      the only clock in the graph
      (8 MSPS, HackRF practical minimum)
    samp_rate: 8e6
    type: fc32
    vga: vga_gain
  states: {}

connections:
- [nut_nut_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_tx_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_1, '0', soapy_hackrf_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
