options:
  parameters:
    author: gr-nut
    description: 'M3 video path validation: NUT video ingest -> raw rgb24 frame dump to a file. No modulator, no display; use video_check.sh to verify the dump byte-exactly against ffmpeg.'
    generate_options: no_gui
    id: video_to_file
    output_language: python
    run_options: run
    title: gr-nut M3 video-to-file dump
  states: {}

blocks:
- name: uri
  id: parameter
  parameters:
    label: NUT FIFO/file
    type: str
    value: /tmp/video.nut
  states: {}
- name: width
  id: parameter
  parameters:
    label: Frame Width
    type: intx
    value: '320'
  states: {}
- name: height
  id: parameter
  parameters:
    label: Frame Height
    type: intx
    value: '240'
  states: {}
- name: outfile
  id: parameter
  parameters:
    label: Output raw rgb24 file
    type: str
    value: frames.rgb
  states: {}
- name: nut_nut_source_video_0
  id: nut_nut_source_video
  parameters:
    command: ''
    comment: |-
      video-only instance (audio_channels=0);
      external mode: command overridden to empty
    uri: uri
    video_height: height
    video_width: width
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: rgb24 frames, back to back
    file: outfile
    type: byte
  states: {}

connections:
- [nut_nut_source_video_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
