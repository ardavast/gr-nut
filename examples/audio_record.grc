options:
  parameters:
    author: gr-nut
    description: 'nut_sink M1 example: signal generator -> NUT Audio Sink with the default spawn command (ffmpeg records /tmp/recording.flac from NUT on its stdin). A K0 chain: no pacer anywhere, so the graph free-runs faster than real time and renders `seconds` seconds of tone in a fraction of that. On completion the sink flushes the muxer, writes the trailer, closes the pipe and WAITS for ffmpeg to finalize the file — the child exiting on its own is the normal end. External-mode variant: pass --command "" --uri FIFO and run your own ffmpeg -i FIFO ... on it.'
    generate_options: no_gui
    id: audio_record
    output_language: python
    run_options: run
    title: gr-nut audio recording example
  states: {}

blocks:
- name: command
  id: parameter
  parameters:
    comment: |-
      spawn mode: full shell command
      reading NUT on stdin, e.g.
      ffmpeg -y -loglevel warning -i pipe:0 out.flac
    label: Spawn Command (spawn mode)
    type: str
    value: ffmpeg -y -loglevel warning -i pipe:0 /tmp/recording.flac
  states: {}
- name: uri
  id: parameter
  parameters:
    comment: |-
      external mode: FIFO/file
      read by your own ffmpeg
    label: NUT FIFO/file (external mode)
    type: str
    value: ''
  states: {}
- name: seconds
  id: parameter
  parameters:
    label: Seconds to record
    type: eng_float
    value: '10'
  states: {}
- name: rate
  id: variable
  parameters:
    comment: |-
      declared to the sink: it writes
      the NUT headers (rate is not adopted)
    value: '48000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    comment: |-
      the media source: a 440 Hz tone
      at the declared 48 kHz
    freq: '440'
    offset: '0'
    phase: '0'
    samp_rate: rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    comment: |-
      bounds the recording; without a
      pacer the graph free-runs (K0)
    num_items: int(seconds * rate)
    type: float
  states: {}
- name: nut_nut_sink_audio_0
  id: nut_nut_sink_audio
  parameters:
    audio_channels: '1'
    audio_rate: rate
    command: command
    comment: |-
      set exactly one of command/uri;
      flush -> trailer -> EOF -> wait for
      ffmpeg to finalize the file
    flush_timeout: '10.0'
    uri: uri
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', nut_nut_sink_audio_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
